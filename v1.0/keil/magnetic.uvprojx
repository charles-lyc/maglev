# Keil uVision project magnetic.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: magnetic
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG STM32F030 USE_STDPERIPH_DRIVER
  c include: ..\src;..\src\Library\STM32F0xx_StdPeriph_Driver\inc;..\src\Application;..\src\Arch;..\src\Arch\stm32f0;..\src\Arch\stm32f0\bare
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group include
    ../src/Application/: configure.h
  group application
    ../src/Application/: main.c pid.c
    ../src/: common use.c
  group arch
    ../src/Library/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
    ../src/Arch/stm32f0/: system_stm32f0xx.c
    ../src/Arch/stm32f0/bare/: gpio.c systick.c serial.c print.c flash.c button.c motor.c adc.c
  group library
    ../src/Library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_dma.c
